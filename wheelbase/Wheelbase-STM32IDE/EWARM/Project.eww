<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Wheelbase-STM32IDE.ewp</path>
  </project>
  <batchBuild />
</workspace>
